# Keil uVision project STM32.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,OLED,uart4
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\User;..\..\User\APP;..\..\User\BSP;..\..\User\BSP\led;..\..\User\BSP\usart1;..\..\User\uC-CPU;..\..\User\uC-CPU\ARM-Cortex-M3\RealView;..\..\User\uC-LIB;..\..\User\uCOS-III\Source;..\..\User\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\User\BSP\lcd;..\..\User\BSP\frame;..\..\User\BSP\usart4;..\..\User\BSP\can;..\..\User\BSP\flash;..\..\User\BSP\fontFlash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group DOC
    ../../Doc/: readme.txt
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uC/CPU
    ../../User/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
    ../../User/uC-CPU/: cpu_core.c
  group uC/LIB
    ../../User/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../User/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../../User/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS-III Port
    ../../User/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group APP
    ../../User/APP/: os_app_hooks.c os_cfg_app.h os_app_hooks.h lib_cfg.h includes.h cpu_cfg.h app_cfg.h os_cfg.h
  group BSP
    ../../User/BSP/led/: bsp_led.c bsp_led.h
    ../../User/BSP/: bsp.c bsp.h
    ../../User/BSP/lcd/: bsp_LCD_I2C.c bsp_LCD_I2C.h codetab.h delay.c delay.h
    ../../User/BSP/key/: bsp_key.c bsp_key.h
    ../../User/BSP/frame/: frame.c frame.h
    ../../User/BSP/usart1/: bsp_usart1.h bsp_usart1.c
    ../../User/BSP/usart4/: bsp_usart4.c bsp_usart4.h
    ../../User/BSP/can/: bsp_can.c bsp_can.h
    ../../User/BSP/flash/: bsp_spi_flash.c bsp_spi_flash.h
    ../../User/BSP/fontFlash/: bsp_font_flash.c bsp_font_flash.h
  group USER
    ../../User/APP/: app.h app.c
    ../../User/: stm32f10x_it.c
